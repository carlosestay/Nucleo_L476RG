# IAR project NucleoL476Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496RG ST STM32L496RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; __cplusplus
  ICCARM.CCIncludePath2: ../Drivers/CMSIS/Include; ../Core/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: NucleoL476Template.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Core/Src/: main.cpp system_stm32l4xx.c
    ./: startup_stm32l476xx.s
  group Core
    ../Core/Src/: button.cpp clock.cpp gpio.cpp hal.cpp led.cpp stopwatch.cpp system.cpp uart.cpp
  group Events
    ../Core/Src/: event.cpp eventManager.cpp
