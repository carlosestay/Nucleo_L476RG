<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project\NucleoL476Template.ewp</path>
    </project>
    <batchBuild />
</workspace>
